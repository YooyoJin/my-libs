# Keil uVision project hc32f460demo.uvprojx, settings and files
target source (6210000::V6.21::ARMCLANG)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32f460demo
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 wLevel=3
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER
  c include: ..\..\source\app\hc32f460demo;..\..\source\common;..\..\source\modules\crc;..\..\source\modules\fanctrl;..\..\source\modules\log;..\..\source\port\hc32f460;..\..\source\vendor\hc32f460\cmsis;..\..\source\vendor\hc32f460\hc32_ll_driver;..\..\source\vendor\hc32f460;..\..\source\vendor\seggerrtt
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group app
    ../../source/app/hc32f460demo/: apptimer.c main.c
  group modules
    ../../source/modules/crc/: crc.c
    ../../source/modules/fanctrl/: fanctrl.c
    ../../source/modules/log/: log.c
  group port
    ../../source/port/hc32f460/: bspclk.c bspdelay.c bspled.c rttlog.c
  group vendor
    ../../source/vendor/hc32f460/hc32_ll_driver/: hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_tmr0.c hc32_ll_tmra.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
    ../../source/vendor/hc32f460/: system_hc32f460.c
    ../../source/vendor/seggerrtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../source/vendor/hc32f460/start/keil/: startup_hc32f460.s
